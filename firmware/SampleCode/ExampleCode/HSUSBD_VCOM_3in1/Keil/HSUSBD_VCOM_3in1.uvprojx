# Keil uVision project HSUSBD_VCOM_3in1.uvprojx, settings and files
target HSUSBD_VCOM_3in1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: HSUSBD_VCOM_3in1
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M460\Include;..\..\..\..\Library\StdDriver\inc;..\..\HSUSBD_VCOM_MultiPort;..\..\common\OLED;..\..\common\LIN;..\..\common
  library: MicroLIB
  memory RVCT4: ROM 0x40000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M460.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M460/Source/: system_M460.c
    ../../../../Library/Device/Nuvoton/M460/Source/ARM/: startup_M460.s
  group User
    ../: main.c descriptors.c vcom_serial.c uart_cfg.c
    ../../common/OLED/: OLED4PINiic.C
    ../../common/: user_timer.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c uart.c retarget.c hsusbd.c gpio.c timer.c
  group LIN
    ../../common/LIN/: LINapp.c LINapp.h
