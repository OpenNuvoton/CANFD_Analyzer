# Keil uVision project 4Port_CANFD_to_SLCAN_by_VCOM.uvprojx, settings and files
target 4Port_CANFD_to_SLCAN_by_VCOM (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: M467HJHAN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.22
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0-0xFFFFF) CLOCK(200000000) CPUTYPE("Cortex-M4") FPU2
  output: 4Port_CANFD_to_SLCAN_by_VCOM +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M460\Include;..\..\..\..\Library\StdDriver\inc;..\..\common\CAN;..\..\common\UART;..\..\common\VCOM;..\..\4Port_CAN_to_SLCAN_by_VCOM;..\..\common;..\..\common\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --map --first='startup_M460.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M460/Source/: system_M460.c
    ../../../../Library/Device/Nuvoton/M460/Source/ARM/: startup_M460.s
  group Library
    ../../../../Library/StdDriver/src/: sys.c i2s.c i2c.c clk.c uart.c retarget.c pdma.c sdh.c gpio.c hsusbd.c canfd.c timer.c
  group Source
    ../: main.c dma_irq.c
    ../../common/: user_timer.c
    ../../common/OLED/: OLED4PINiic.C
  group VCOM
    ../../common/VCOM/: descriptors.c vcom_serial.c VCOMapp.c
  group CAN
    ../../common/CAN/: CANapp.c slcan.c
  group UART
    ../../common/UART/: UART0_DMA.c
