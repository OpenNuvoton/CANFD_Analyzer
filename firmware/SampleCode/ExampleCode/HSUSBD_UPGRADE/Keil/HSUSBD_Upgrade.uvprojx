# Keil uVision project HSUSBD_Upgrade.uvprojx, settings and files
target HSUSBD_Upgrade (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: M467SJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: HSUSBD_UPGRADE
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M460\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\FatFs\source;..\upgrade;..\..\common\OLED;..\..\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: ..\upgrade\usbd_firmware_update.sct
  link misc: --map  --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M460/Source/: system_M460.c
    ../../../../Library/Device/Nuvoton/M460/Source/ARM/: startup_M460.s
  group User
    ../: main.c descriptors.c massstorage.c
    ../../common/: user_boot.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c uart.c retarget.c hsusbd.c sdh.c fmc.c gpio.c crc.c timer.c
  group upgrade
    ../upgrade/: usbd_update.c sdglue.c
  group FatFs
    ../../../../ThirdParty/FatFs/source/: ff.c
    ../: diskio.c
  group OLED
    ../../common/OLED/: OLED4PINiic.C
