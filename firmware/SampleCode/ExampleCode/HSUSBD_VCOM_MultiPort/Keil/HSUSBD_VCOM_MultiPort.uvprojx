# Keil uVision project HSUSBD_VCOM_MultiPort.uvprojx, settings and files
target HSUSBD_VCOM_MultiPort (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: M467SJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: HSUSBD_VCOM_MultiPort
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M460\Include;..\..\..\..\Library\StdDriver\inc;..\..\HSUSBD_VCOM_MultiPort;..\..\common\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --map --first='startup_M460.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M460/Source/: system_M460.c
    ../../../../Library/Device/Nuvoton/M460/Source/ARM/: startup_M460.s
  group User
    ../: main.c descriptors.c vcom_serial.c uart_cfg.c
    ../../common/OLED/: OLED4PINiic.C
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c uart.c retarget.c hsusbd.c gpio.c
